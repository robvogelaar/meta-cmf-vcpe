DEPENDS_remove = " kernel-autoconf"
